# Keil uVision project Userused.uvproj, settings and files
target User (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Userused +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\header;..\src;..\src\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group UserData
    ../src/: UserFunction.c
  group Lib
    ../src/: stm32f4xx_it.c main.c startup_stm32f4xx.s
    ../lib/: base_empty.lib
