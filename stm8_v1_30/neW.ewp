# IAR project neW.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: neW.srec
  ILINK.IlinkOutputFile: neW.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
configuration HC_SR04 (STM8, debug)
  as the first configuration, except:
configuration AD (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; USER\AD
configuration GY_271 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SS_key (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
  group ADs
    USER/AD/: ADc.c ADc.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group GY_271
    USER/GY_271/: HMC5833.c I2C_IO.c main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group HC_SR04
    USER/HC_SR04/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group SS_key
    USER/SS_key/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group user
    ./: main.c SHT10.c SHT10_01.c stm8s_conf.h stm8s_it.c stm8s_it.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h
